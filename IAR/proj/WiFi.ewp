# IAR project WiFi.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ..\app; ..\..\Examples; ..\..\Port\CoX Freescale\CoX_Peripheral_KLx\libcox; ..\..\WiFi_Lib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WiFi.srec
  ILINK.IlinkOutputFile: WiFi.out
  ILINK.IlinkIcfFile: F:\Arduino_WiFi_Driver\IAR\proj\16KB_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Freedom (ARM, debug)
  as the first configuration, except:
  group app
    ../app/: main.c
  group Examples
    ../../Examples/: ConnectNoEncryption.c ConnectWithWEP.c ConnectWithWPA.c ScanNetworks.c WifiPachubeClient.c WifiPachubeClientString.c WifiWebClient.c WifiWebClientRepeating.c WifiWebServer.c
  group Freescale_Lib/inc
    ../../Port/CoX Freescale/CoX_Peripheral_KLx/libcox/: xacmp.h xadc.h xcore.h xdebug.h xdma.h xgpio.h xhw_acmp.h xhw_adc.h xhw_dma.h xhw_gpio.h xhw_i2c.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_rtc.h xhw_spi.h xhw_sysctl.h xhw_tpm.h xhw_types.h xhw_uart.h xhw_wdt.h xi2c.h xpwm.h xrtc.h xspi.h xsysctl.h xuart.h xwdt.h
  group Freescale_Lib/src
    ../../Port/CoX Freescale/CoX_Peripheral_KLx/libcox/: xacmp.c xadc.c xcore.c xdebug.c xdma.c xgpio.c xi2c.c xpwm.c xrtc.c xspi.c xsysctl.c xuart.c xwdt.c
  group Startup
    ../../Port/CoX Freescale/CoX_Peripheral_KLx/startup/src/: startup_ewarm.s
  group WiFi_Lib/inc
    ../../WiFi_Lib/: server_drv.h spi_drv.h WiFi.h wifi_drv.h wifi_spi.h WiFiClient.h WiFiServer.h wl_definitions.h wl_types.h
  group WiFi_Lib/src
    ../../WiFi_Lib/: server_drv.c spi_drv.c WiFi.c wifi_drv.c WiFiClient.c WiFiServer.c
