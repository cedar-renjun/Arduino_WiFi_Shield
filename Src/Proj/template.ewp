# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ..\CoX_Peripheral_KLx\libcox; ..\WiFi_Lib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: F:\Freedom WiFi Driver\Src\Proj\128KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../App/: DebugPort.c main.c WifiPachubeClient.c WifiWebClient.c WifiWebServer.c
  group Cox_Lib/inc
    ../CoX_Peripheral_KLx/libcox/: xacmp.h xadc.h xcore.h xdebug.h xdma.h xgpio.h xhw_acmp.h xhw_adc.h xhw_dma.h xhw_gpio.h xhw_i2c.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_rtc.h xhw_spi.h xhw_sysctl.h xhw_tpm.h xhw_types.h xhw_uart.h xhw_wdt.h xi2c.h xpwm.h xrtc.h xspi.h xsysctl.h xuart.h xwdt.h
  group Cox_Lib/src
    ../CoX_Peripheral_KLx/libcox/: xacmp.c xadc.c xcore.c xdebug.c xdma.c xgpio.c xi2c.c xpwm.c xrtc.c xspi.c xsysctl.c xuart.c xwdt.c
  group Startup
    ../CoX_Peripheral_KLx/startup/: startup_ewarm.s
  group WiFi_Lib/inc
    ../WiFi_Lib/: server_drv.h socket.h spi_drv.h WiFi.h wifi_drv.h wifi_spi.h WiFiClient.h WiFiServer.h wl_definitions.h wl_types.h
  group WiFi_Lib/src
    ../WiFi_Lib/: server_drv.c socket.c spi_drv.c WiFi.c wifi_drv.c WiFiClient.c WiFiServer.c
