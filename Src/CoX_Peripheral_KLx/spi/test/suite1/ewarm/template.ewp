# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ..\..\..\..\; ..\..\..\..\libcox; ..\..\..\..\startup; ..\..\..\..\..\WiFi_Lib; ..\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: F:\Cox\CoX_Peripheral\CoX_Peripheral_KLx\spi\test\suite1\ewarm\128KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group ewarm
    ../../../../startup/src/: startup_ewarm.s
  group libcox_inc
    ../../../../libcox/: xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_spi.h xhw_sysctl.h xhw_types.h xhw_uart.h xspi.h xsysctl.h xuart.h
  group libcox_src
    ../../../../libcox/: xcore.c xdebug.c xgpio.c xspi.c xsysctl.c xuart.c
  group Source
    ../../../../testframe/: main.c test.c testport.c
    ../../../../../../../Arduino_WiFi_Driver/Examples/: WifiPachubeClient.c
  group WiFi_Lib/inc
    ../../../../../../../Arduino_WiFi_Driver/WiFi_Lib/: server_drv.h socket.h spi_drv.h WiFi.h wifi_drv.h wifi_spi.h WiFiClient.h WiFiServer.h wl_definitions.h wl_types.h
  group WiFi_Lib/src
    ../../../../../../../Arduino_WiFi_Driver/WiFi_Lib/: server_drv.c socket.c spi_drv.c WiFi.c wifi_drv.c WiFiClient.c WiFiServer.c
