# IAR project spiMaster.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S9B96 TexasInstruments LM3S9B96
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; xDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\; ..\..\..\..\libcox; ..\..\..\..\startup; ..\; ..\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: spiMaster.srec
  ILINK.IlinkOutputFile: spiMaster.out
  ILINK.IlinkIcfFile: C:\Users\renjun\Desktop\Cox\CoX_Peripheral\CoX_Peripheral_KLx\spi\example\SpiMaster\ewarm\16KB_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group ewarm
    ../../../../startup/src/: startup_ewarm.s
  group libcox_inc
    ../../../../libcox/: xcore.h xdebug.h xgpio.h xhw_gpio.h xhw_ints.h xhw_memmap.h xhw_nvic.h xhw_spi.h xhw_sysctl.h xhw_types.h xhw_uart.h xspi.h xsysctl.h xuart.h
  group libcox_src
    ../../../../libcox/: xcore.c xdebug.c xgpio.c xspi.c xsysctl.c xuart.c
  group main
    ../: main.c
  group Source
    ../src/: SpiMaster.c
